# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD MPU6050
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\System;.\User;.\Peripheral;.\Hardware;.\Peripheral\GPIO;.\Peripheral\TIM;.\Peripheral\IIC;.\Peripheral\ENCODER;.\Peripheral\USART;.\Peripheral\ADC;.\Hardware\MOTOR;.\Hardware\MPU6050;.\Hardware\UltraSound;.\Hardware\CC2530;.\Software;.\Software\PID;.\Software\MyTask;.\Software\DMP;.\Software\Delay;.\Software\Receive;.\Software\Manual;.\Software\Reply;.\Software\Data;.\FreeRTOS\FreeRTOS_CORE;.\FreeRTOS\FreeRTOS_PORT;.\FreeRTOS\FreeRTOS_CORE\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: sys.c sys.h
  group Peripheral
    ./Peripheral/GPIO/: GPIO.c GPIO.h
    ./Peripheral/TIM/: TIM.c TIM.h
    ./Peripheral/IIC/: IIC.c IIC.h
    ./Peripheral/USART/: USART.c USART.h
    ./Peripheral/ENCODER/: ENCODER.c ENCODER.h
    ./Peripheral/ADC/: ADC.c ADC.h
  group Hardware
    ./Hardware/MOTOR/: MOTOR.c MOTOR.h
    ./Hardware/MPU6050/: MPU6050.c MPU6050.h
  group Software
    ./Software/MyTask/: MyTask.c MyTask.h
    ./Software/PID/: PID.c PID.h
    ./Software/Delay/: Delay.c Delay.h
    ./Software/DMP/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
    ./Software/Receive/: Receive.c Receive.h
    ./Software/Reply/: Reply.c Reply.h
    ./Software/Manual/: Manual.c Manual.h
    ./Software/Data/: Data.c Data.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h main.h
  group FreeRTOS_CORE
    ./FreeRTOS/FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/FreeRTOS_CORE/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS_PORT
    ./FreeRTOS/FreeRTOS_PORT/: heap_4.c port.c portmacro.h
